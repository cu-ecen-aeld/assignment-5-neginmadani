## base_external/package/ldd3/Config.in
```kconfig
config BR2_PACKAGE_LDD3
	bool "ldd3"
	help
	  Includes the scull and misc-modules packages.
```
